do_install_append() {
	rm ${D}/usr/include/iconv.h
}
